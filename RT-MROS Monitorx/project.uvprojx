# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA6M3AH Renesas
  pack: Renesas.RA_DFP.5.1.0
  cpu: IRAM(0x1FFE0000,0x020000) IRAM2(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall  -Wmissing-declarations  -Wpointer-arith  -Waggregate-return -Wfloat-equal
  c include: rt-thread\components\drivers\include;packages\LVGL-v8.3.6\src\draw\sdl;packages\LVGL-v8.3.6\src\extra\widgets\keyboard;rt-thread\components\drivers\include;packages\LVGL-v8.3.6\src\extra\widgets\spinner;packages\LVGL-v8.3.6\src\extra\widgets\calendar;board\ports\touch\gt911\inc;rt-thread\components\drivers\include;packages\LVGL-v8.3.6\src\misc;packages\LVGL-v8.3.6\src\extra\widgets\menu;packages\LVGL-v8.3.6\src\extra\libs\bmp;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.6\src\extra\themes;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-v8.3.6\src\extra\widgets\animimg;packages\LVGL-v8.3.6\src\extra\others;board\ports\wifi;packages\LVGL-v8.3.6\src\font;packages\LVGL-v8.3.6\src\extra\themes\mono;.;packages\LVGL-v8.3.6\src\draw\sw;packages\LVGL-v8.3.6\src\extra\libs;packages\LVGL-v8.3.6\src\core;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;packages\LVGL-v8.3.6\src\draw;packages\LVGL-v8.3.6\src\extra\widgets\tabview;packages\LVGL-v8.3.6\src\extra\widgets\led;packages\LVGL-v8.3.6\src\extra\themes\basic;packages\LVGL-v8.3.6\src\extra\widgets\tileview;packages\LVGL-v8.3.6\src\draw\nxp\vglite;packages\LVGL-v8.3.6\src\extra\others\imgfont;packages\LVGL-v8.3.6\src\draw\nxp\pxp;libraries\HAL_Drivers\config;packages\LVGL-v8.3.6\src\extra\libs\rlottie;packages\LVGL-v8.3.6\src\extra\others\snapshot;packages\LVGL-v8.3.6\src\extra;packages\LVGL-v8.3.6\src\extra\widgets\chart;packages\LVGL-v8.3.6\src\extra\layouts\grid;packages\LVGL-v8.3.6\src;packages\LVGL-v8.3.6\src\extra\widgets\span;packages\LVGL-v8.3.6\src\extra\widgets\win;libraries\HAL_Drivers;packages\LVGL-v8.3.6\src\extra\layouts\flex;packages\LVGL-v8.3.6\src\extra\widgets;rt-thread\components\libc\posix\io\poll;src;board\lvgl;packages\LVGL-v8.3.6\src\extra\widgets\msgbox;board;packages\LVGL-v8.3.6\src\extra\libs\fsdrv;packages\LVGL-v8.3.6\src\widgets;packages\LVGL-v8.3.6\src\draw\swm341_dma2d;packages\LVGL-v8.3.6\src\extra\others\gridnav;rt-thread\components\finsh;packages\LVGL-v8.3.6\src\extra\libs\gif;packages\LVGL-v8.3.6\src\extra\others\msg;packages\LVGL-v8.3.6\env_support\rt-thread;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.6\src\draw\stm32_dma2d;packages\LVGL-v8.3.6\src\extra\libs\png;rt-thread\include;packages\LVGL-v8.3.6\src\extra\widgets\colorwheel;packages\LVGL-v8.3.6\src\hal;board\ports;packages\LVGL-v8.3.6\src\extra\libs\sjpg;packages\LVGL-v8.3.6\src\extra\others\monkey;rt-thread\components\libc\compilers\common\include;packages\LVGL-v8.3.6\src\extra\widgets\imgbtn;packages\LVGL-v8.3.6\src\extra\widgets\list;rt-thread\components\libc\posix\io\epoll;packages\LVGL-v8.3.6\src\extra\widgets\meter;packages\LVGL-v8.3.6\src\extra\libs\freetype;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.6\src\extra\libs\ffmpeg;packages\LVGL-v8.3.6\src\extra\layouts;packages\LVGL-v8.3.6\src\extra\others\fragment;packages\LVGL-v8.3.6\src\extra\themes\default;packages\LVGL-v8.3.6\src\extra\others\ime;packages\LVGL-v8.3.6\src\extra\libs\qrcode;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.6\src\extra\widgets\spinbox;rt-thread\libcpu\arm\cortex-m4;packages\LVGL-v8.3.6\src\draw\arm2d
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/: ra6m3_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_soft_i2c.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group gt911
    board/ports/touch/gt911/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group LVGL
    packages/LVGL-v8.3.6/src/font/: lv_font_montserrat_22.c lv_font_montserrat_14.c lv_font_unscii_8.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_24.c lv_font_loader.c lv_font_montserrat_28_compressed.c lv_font_montserrat_12.c lv_font_montserrat_8.c lv_font_montserrat_30.c lv_font_montserrat_26.c lv_font_simsun_16_cjk.c lv_font_montserrat_28.c lv_font_montserrat_38.c lv_font_montserrat_36.c lv_font_montserrat_40.c lv_font_montserrat_34.c lv_font_montserrat_42.c lv_font_fmt_txt.c lv_font_montserrat_44.c lv_font_montserrat_12_subpx.c lv_font.c lv_font_montserrat_20.c lv_font_montserrat_10.c lv_font_montserrat_32.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_46.c lv_font_unscii_16.c lv_font_montserrat_48.c
    packages/LVGL-v8.3.6/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.6/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c lv_draw_pxp.c
    packages/LVGL-v8.3.6/src/misc/: lv_ll.c lv_log.c lv_style.c lv_bidi.c lv_area.c lv_txt_ap.c lv_anim.c lv_color.c lv_style_gen.c lv_utils.c lv_gc.c lv_fs.c lv_tlsf.c lv_txt.c lv_math.c lv_mem.c lv_async.c lv_templ.c lv_anim_timeline.c lv_timer.c lv_lru.c lv_printf.c
    packages/LVGL-v8.3.6/src/draw/: lv_draw_rect.c lv_draw_img.c lv_draw_transform.c lv_draw_label.c lv_draw_triangle.c lv_draw_arc.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c
    packages/LVGL-v8.3.6/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.6/src/draw/nxp/vglite/: lv_draw_vglite.c lv_vglite_utils.c lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_vglite_buf.c
    packages/LVGL-v8.3.6/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.6/src/widgets/: lv_btn.c lv_btnmatrix.c lv_switch.c lv_dropdown.c lv_line.c lv_checkbox.c lv_objx_templ.c lv_img.c lv_label.c lv_roller.c lv_arc.c lv_canvas.c lv_slider.c lv_table.c lv_textarea.c lv_bar.c
    packages/LVGL-v8.3.6/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.6/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.6/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.6/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.6/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.6/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_letter.c lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw_layer.c lv_draw_sw_rect.c lv_draw_sw.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw_blend.c lv_draw_sw_polygon.c lv_draw_sw_line.c
    packages/LVGL-v8.3.6/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.6/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.6/src/core/: lv_event.c lv_obj_scroll.c lv_obj_class.c lv_obj_style_gen.c lv_obj_draw.c lv_disp.c lv_obj.c lv_indev.c lv_indev_scroll.c lv_obj_style.c lv_group.c lv_obj_pos.c lv_refr.c lv_theme.c lv_obj_tree.c
    packages/LVGL-v8.3.6/src/draw/sdl/: lv_draw_sdl_composite.c lv_draw_sdl_layer.c lv_draw_sdl_bg.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl_polygon.c lv_draw_sdl_img.c lv_draw_sdl_line.c lv_draw_sdl.c lv_draw_sdl_rect.c lv_draw_sdl_arc.c lv_draw_sdl_label.c lv_draw_sdl_mask.c
    packages/LVGL-v8.3.6/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_win32.c lv_fs_fatfs.c lv_fs_posix.c
    packages/LVGL-v8.3.6/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.6/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.6/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.6/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.6/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.6/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.6/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.6/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.6/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.6/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.6/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.6/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.6/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.6/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.6/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.6/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.6/src/hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    packages/LVGL-v8.3.6/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.6/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.6/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.6/src/extra/: lv_extra.c
    packages/LVGL-v8.3.6/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.6/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.6/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.6/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.6/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.6/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.6/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.6/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.6/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.6/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.6/src/extra/widgets/list/: lv_list.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.6/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    packages/LVGL-v8.3.6/env_support/rt-thread/squareline/ui/components/: ui_comp.c ui_comp_hook.c ui_comp_bar1.c ui_comp_next_figure.c ui_comp_wifi.c
    packages/LVGL-v8.3.6/env_support/rt-thread/squareline/ui/screens/: ui_Main_Screen.c ui_start_menu.c
    packages/LVGL-v8.3.6/env_support/rt-thread/squareline/ui/images/: ui_img_terminal_png.c ui_img_close_png.c ui_img_tortle_background_png.c ui_img_1915926208.c ui_img_microros_rtt_png.c ui_img_1650958959.c ui_img_return_png.c ui_img_turtle_png.c ui_img_startup_png.c ui_img_serial_png.c ui_img_1383021239.c
    packages/LVGL-v8.3.6/env_support/rt-thread/squareline/ui/: ui_helpers.c ui_events.c ui.c
    packages/LVGL-v8.3.6/env_support/rt-thread/squareline/: lv_ui_entry.c
  group src
    src/: micro_entity.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
